# BASE-TPM-10, BASE-TPM-12: FAPI is disabled by default in kirkstone
PACKAGECONFIG:append = " fapi"
