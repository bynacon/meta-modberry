FILESEXTRAPATHS:prepend := "${THISDIR}/patches:"
SRC_URI += " file://0001-configs-rpi-cm4-enable-pci.patch "